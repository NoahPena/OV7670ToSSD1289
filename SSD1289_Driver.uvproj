# Keil uVision project SSD1289_Driver.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: SSD1289_Driver
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Startup.s Main.c SysTick.c SSD1289.c SSD1289.h SysTick.h Main.h Port Definitions.txt XPT2046.c XPT2046.h ADC.c ADC.h OV7670.c OV7670.h OV7670reg.h
